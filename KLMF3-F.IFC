Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten\R&D\Producttekeningen\7. GROENGEVELS (green facades)\KLMF1-2-3 brontekeningen\KLMF3-F.IFC
Time: 2026-09-03T08:21:55+00:00
Author: none
Organization: none
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3
Authorization: none

# IfcProject, Project
Description: Default Project
